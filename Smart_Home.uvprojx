# Keil uVision project Smart_Home.uvprojx, settings and files
target Smart_Home (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Home
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\HARDWARE\inc;.\USER\inc;.\STM32F10x_StdPeriph_Driver\inc;.\Gizwits;.\Utils;.\FreeRTOS\include;.\FreeRTOS\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
    ./FreeRTOS/port/: FreeRTOSConfig.h
  group USER
    ./USER/src/: main.c delay.c usart1.c tim1.c tim4.c app.c
  group HARDWARE
    ./HARDWARE/inc/: pic.h default.h
    ./HARDWARE/src/: led.c key.c relay.c motor.c rgb.c dht11.c oled.c step_motor.c remote.c wifi.c
  group LIB
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Gizwits
    ./Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ./Utils/: common.c dataPointTools.c ringbuffer.c
  group FreeRTOS/port
    ./FreeRTOS/port/: heap_4.c port.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
